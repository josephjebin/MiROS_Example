# Keil uVision project lesson.uvprojx, settings and files
target dbg (6220000::V6.22::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c misc: -Wno-declaration-after-statement
  c include: ..\CMSIS\Include;..\ek-tm4c123gxl;C:\qp\qpc\include
  asm define: Stack_Size=2048,Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: lesson.sct
  group Source
    ./: main.c bsp.c bsp.h miros.c miros.h
    C:/qp/qpc/include/: qassert.h
  group ek-tm4c123gxl
    ../ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
    ../ek-tm4c123gxl/: system_TM4C123GH6PM.c
